# Repository Alexdelia/keyboard (continued)

## KiCad design keyboard/icarus/pcb/right/right.kicad_pcb (continued)

Board: 2 copper layers, 145 parts (111 on the bottom side), 68 nets, no tracks yet.

Other parts of the board:
K1: top-pinkyOuter; Gateron_KS33_Magnetic_Jade
K2: home-pinkyOuter; Gateron_KS33_Magnetic_Jade
K3: bottom-pinkyOuter; Gateron_KS33_Magnetic_Jade
K4: number-pinky; Gateron_KS33_Magnetic_Jade
K5: top-pinky; Gateron_KS33_Magnetic_Jade
K6: home-pinky; Gateron_KS33_Magnetic_Jade
K7: bottom-pinky; Gateron_KS33_Magnetic_Jade
K8: number-ring; Gateron_KS33_Magnetic_Jade
K9: top-ring; Gateron_KS33_Magnetic_Jade
K10: home-ring; Gateron_KS33_Magnetic_Jade
K11: bottom-ring; Gateron_KS33_Magnetic_Jade
K12: number-middle; Gateron_KS33_Magnetic_Jade
K13: top-middle; Gateron_KS33_Magnetic_Jade
K14: home-middle; Gateron_KS33_Magnetic_Jade
K15: bottom-middle; Gateron_KS33_Magnetic_Jade
K16: number-index; Gateron_KS33_Magnetic_Jade
K17: top-index; Gateron_KS33_Magnetic_Jade
K18: home-index; Gateron_KS33_Magnetic_Jade
K19: bottom-index; Gateron_KS33_Magnetic_Jade
K20: number-indexInner; Gateron_KS33_Magnetic_Jade
K21: top-indexInner; Gateron_KS33_Magnetic_Jade
K22: home-indexInner; Gateron_KS33_Magnetic_Jade
K23: bottom-indexInner; Gateron_KS33_Magnetic_Jade
K24: thumb0; Gateron_KS33_Magnetic_Jade
K25: thumb1; Gateron_KS33_Magnetic_Jade
K26: thumb2; Gateron_KS33_Magnetic_Jade
K27: thumb3; Gateron_KS33_Magnetic_Jade
MH1, MH2, MH3, MH4, MH5, MH6: M2; MountingHole_2.2mm_M2
